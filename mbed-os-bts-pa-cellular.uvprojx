# Keil uVision project mbed-os-bts-pa-cellular.uvprojx, settings and files
target mbed-os-bts-pa-cellular (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: EFM32WG990F256 Silicon Labs
  pack: SiliconLabs.EFM32WG_DFP.5.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mbed-os-bts-pa-cellular
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_EFM32WG990F256 --preinclude=mbed_config.h -DMBEDTLS_CONFIG_HW_SUPPORT -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_Silicon_Labs -DTARGET_LIKE_CORTEX_M4 --split_sections -DTARGET_EFM32WG_STK3800 --no_rtti -DDEVICE_I2C_ASYNCH=1 -c -DTARGET_RTOS_M4_M7 -DTARGET_256K -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTINOUT=1 -D__CORTEX_M4 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DMBED_BUILD_TIMESTAMP=1526133188.23 -DEFM32WG990F256 --apcs=interwork -DDEVICE_I2C=1 -DTARGET_CORTEX -DTARGET_SL_AES -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DFEATURE_COMMON_PAL=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DMBED_TICKLESS -DTARGET_EFM32WG -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_EFM32 -D__MBED_CMSIS_RTOS_CM -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=4
  c include: .;mbed-os/.;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/greentea-client/source;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/source;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/source;mbed-os/features/frameworks/utest/utest;mbed-os/features/mbedtls;mbed-os/features/mbedtls/importer;mbed-os/features/mbedtls/inc;mbed-os/features/mbedtls/inc/mbedtls;mbed-os/features/mbedtls/src;mbed-os/features/mbedtls/platform;mbed-os/features/mbedtls/platform/inc;mbed-os/features/mbedtls/platform/src;mbed-os/features/mbedtls/targets;mbed-os/features/mbedtls/targets/TARGET_Silicon_Labs;mbed-os/features/nanostack;mbed-os/features/storage;mbed-os/features/netsocket;mbed-os/features/netsocket/cellular;mbed-os/features/netsocket/cellular/generic_modem_driver;mbed-os/features/filesystem;mbed-os/features/filesystem/bd;mbed-os/features/filesystem/fat;mbed-os/features/filesystem/fat/ChaN;mbed-os/features/filesystem/littlefs;mbed-os/features/filesystem/littlefs/littlefs;mbed-os/features/cellular;mbed-os/features/cellular/easy_cellular;mbed-os/features/cellular/framework;mbed-os/features/cellular/framework/API;mbed-os/features/cellular/framework/AT;mbed-os/features/cellular/framework/common;mbed-os/features/cellular/framework/targets;mbed-os/features/cellular/framework/targets/QUECTEL;mbed-os/features/cellular/framework/targets/QUECTEL/BC95;mbed-os/features/cellular/framework/targets/QUECTEL/BG96;mbed-os/features/cellular/framework/targets/TELIT;mbed-os/features/cellular/framework/targets/TELIT/HE910;mbed-os/features/cellular/framework/targets/UBLOX;mbed-os/features/cellular/framework/targets/UBLOX/LISA_U;mbed-os/features/lorawan;mbed-os/features/lorawan/lorastack;mbed-os/features/lorawan/lorastack/mac;mbed-os/features/lorawan/lorastack/phy;mbed-os/features/lorawan/system;mbed-os/features/nvstore;mbed-os/features/nvstore/source;mbed-os/cmsis;mbed-os/cmsis/TARGET_CORTEX_M;mbed-os/drivers;mbed-os/events;mbed-os/events/equeue;mbed-os/rtos;mbed-os/rtos/TARGET_CORTEX;mbed-os/rtos/TARGET_CORTEX/rtx4;mbed-os/rtos/TARGET_CORTEX/rtx5;mbed-os/rtos/TARGET_CORTEX/rtx5/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7;mbed-os/rtos/TARGET_CORTEX/rtx5/Source;mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M;mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_ARM;mbed-os/hal;mbed-os/hal/storage_abstraction;mbed-os/platform;mbed-os/targets;mbed-os/targets/TARGET_Silicon_Labs;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/TARGET_EFM32WG_STK3800;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device/TARGET_256K;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device/TARGET_256K/TOOLCHAIN_ARM_STD;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/common;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/emlib;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/emlib/inc;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/emlib/src;mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/trng;mbed-os/features/FEATURE_COMMON_PAL;mbed-os/features/FEATURE_COMMON_PAL/mbed-coap;mbed-os/features/FEATURE_COMMON_PAL/mbed-coap/doxygen;mbed-os/features/FEATURE_COMMON_PAL/mbed-coap/mbed-coap;mbed-os/features/FEATURE_COMMON_PAL/mbed-coap/source;mbed-os/features/FEATURE_COMMON_PAL/mbed-coap/source/include;mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib;mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib;mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/platform;mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/source;mbed-os/features/FEATURE_COMMON_PAL/mbed-trace;mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/mbed-trace;mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/source;mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos;mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/cs_nvm;mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/nvm;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/platform;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/IPv6_fcf_lib;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libBits;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libList;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace/scripts;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libip6string;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nsdynmemLIB;mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nvmHelper;mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop;mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop;mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/platform;mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/source;mbed-os/features/FEATURE_LWIP;mbed-os/features/FEATURE_LWIP/lwip-interface;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/prot;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/polarssl;.\BG96;.\BG96\ATParser;.\BG96\ATParser\BufferedSerial;.\BG96\ATParser\BufferedSerial\Buffer
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DEFM32WG990F256,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DTRANSACTION_QUEUE_SIZE_SPI=4,-DMBED_TICKLESS,-DMBEDTLS_CONFIG_HW_SUPPORT
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device/TARGET_256K/TOOLCHAIN_ARM_STD/efm32wg.sct
  link misc: --show_full_path
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/features/mbedtls/targets/TARGET_Silicon_Labs/: aes_aes.c aes_alt.h crypto_aes.c crypto_ecp.c crypto_management.c crypto_management.h crypto_sha.c mbedtls_device.h sha1_alt.h sha256_alt.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/: analogin_api.c analogout_api.c dma_api.c dma_api_HAL.h flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c itm_api.c lp_ticker.c PeripheralNames.h PeripheralPins.h pinmap.c pinmap_function.c pinmap_function.h port_api.c pwmout_api.c rtc_api.c rtc_api_HAL.h serial_api.c serial_api_HAL.h sleep.c spi_api.c us_ticker.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h critical_section_api.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h lwip_errno.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
    mbed-os/features/cellular/easy_cellular/: APN_db.h CellularConnectionFSM.cpp CellularConnectionFSM.h EasyCellularConnection.cpp EasyCellularConnection.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/: arm_hal_interrupt.c arm_hal_interrupt_private.h arm_hal_random.c arm_hal_timer.cpp ns_event_loop.c ns_event_loop.h ns_hal_init.c ns_hal_init.h
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
    mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/features/cellular/framework/AT/: AT_CellularBase.cpp AT_CellularBase.h AT_CellularDevice.cpp AT_CellularDevice.h AT_CellularInformation.cpp AT_CellularInformation.h AT_CellularNetwork.cpp AT_CellularNetwork.h AT_CellularPower.cpp AT_CellularPower.h AT_CellularSIM.cpp AT_CellularSIM.h AT_CellularSMS.cpp AT_CellularSMS.h AT_CellularStack.cpp AT_CellularStack.h ATHandler.cpp ATHandler.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h lwip_ethernet.h mld6.h nd6.h tcp.h udp.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h ExhaustibleBlockDevice.cpp ExhaustibleBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ObservingBlockDevice.cpp ObservingBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h ReadOnlyBlockDevice.cpp ReadOnlyBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch/: cc.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c perf.h sys_arch.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
    mbed-os/features/netsocket/: CellularBase.h CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_ppp.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    mbed-os/features/cellular/framework/API/: CellularDevice.h CellularInformation.h CellularNetwork.h CellularPower.h CellularSIM.h CellularSMS.h
    mbed-os/features/cellular/framework/common/: CellularList.h CellularLog.h CellularTargets.h CellularUtil.cpp CellularUtil.h
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/common/: clocking.h cmsis.h cmsis_nvic.h CommonPinNames.h device.h mbed_overrides.c objects.h PortNames.h
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libBits/: common_functions.c
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/: common_functions.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
    mbed-os/rtos/: ConditionVariable.cpp ConditionVariable.h EventFlags.cpp EventFlags.h Kernel.cpp Kernel.h Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/cs_nvm/: cs_nvm.c
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/TARGET_EFM32WG_STK3800/: device_peripherals.h PinNames.h
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/features/filesystem/fat/ChaN/: diskio.h ff.cpp ff.h ffconf.h ffunicode.cpp integer.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device/: efm32wg230f128.h efm32wg230f256.h efm32wg230f64.h efm32wg232f128.h efm32wg232f256.h efm32wg232f64.h efm32wg280f128.h efm32wg280f256.h efm32wg280f64.h efm32wg290f128.h efm32wg290f256.h efm32wg290f64.h efm32wg295f128.h efm32wg295f256.h efm32wg295f64.h efm32wg330f128.h efm32wg330f256.h efm32wg330f64.h efm32wg332f128.h efm32wg332f256.h efm32wg332f64.h efm32wg360f128.h efm32wg360f256.h efm32wg360f64.h efm32wg380f128.h efm32wg380f256.h efm32wg380f64.h efm32wg390f128.h efm32wg390f256.h efm32wg390f64.h efm32wg395f128.h efm32wg395f256.h efm32wg395f64.h efm32wg840f128.h efm32wg840f256.h efm32wg840f64.h efm32wg842f128.h efm32wg842f256.h efm32wg842f64.h efm32wg880f128.h efm32wg880f256.h efm32wg880f64.h efm32wg890f128.h efm32wg890f256.h efm32wg890f64.h efm32wg895f128.h efm32wg895f256.h efm32wg895f64.h efm32wg900f256.h efm32wg940f128.h efm32wg940f256.h efm32wg940f64.h efm32wg942f128.h efm32wg942f256.h efm32wg942f64.h efm32wg980f128.h efm32wg980f256.h efm32wg980f64.h efm32wg990f128.h efm32wg990f256.h efm32wg990f64.h efm32wg995f128.h efm32wg995f256.h efm32wg995f64.h efm32wg_acmp.h efm32wg_adc.h efm32wg_aes.h efm32wg_af_pins.h efm32wg_af_ports.h efm32wg_burtc.h efm32wg_burtc_ret.h efm32wg_calibrate.h efm32wg_cmu.h efm32wg_dac.h efm32wg_devinfo.h efm32wg_dma.h efm32wg_dma_ch.h efm32wg_dma_descriptor.h efm32wg_dmactrl.h efm32wg_dmareq.h efm32wg_ebi.h efm32wg_emu.h efm32wg_etm.h efm32wg_fpueh.h efm32wg_gpio.h efm32wg_gpio_p.h efm32wg_i2c.h efm32wg_lcd.h efm32wg_lesense.h efm32wg_lesense_buf.h efm32wg_lesense_ch.h efm32wg_lesense_st.h efm32wg_letimer.h efm32wg_leuart.h efm32wg_msc.h efm32wg_pcnt.h efm32wg_prs.h efm32wg_prs_ch.h efm32wg_prs_signals.h efm32wg_rmu.h efm32wg_romtable.h efm32wg_rtc.h efm32wg_timer.h efm32wg_timer_cc.h efm32wg_uart.h efm32wg_usart.h efm32wg_usb.h efm32wg_usb_diep.h efm32wg_usb_doep.h efm32wg_usb_hc.h efm32wg_vcmp.h efm32wg_wdog.h em_device.h system_efm32wg.c system_efm32wg.h
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_can.c em_cmu.c em_core.c em_cryotimer.c em_crypto.c em_csen.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_qspi.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_vdac.c em_wdog.c
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/emlib/inc/: em_acmp.h em_adc.h em_aes.h em_assert.h em_burtc.h em_bus.h em_can.h em_chip.h em_cmu.h em_common.h em_core.h em_cryotimer.h em_crypto.h em_csen.h em_dac.h em_dbg.h em_dma.h em_ebi.h em_emu.h em_gpcrc.h em_gpio.h em_i2c.h em_idac.h em_lcd.h em_ldma.h em_lesense.h em_letimer.h em_leuart.h em_mpu.h em_msc.h em_opamp.h em_pcnt.h em_prs.h em_qspi.h em_ramfunc.h em_rmu.h em_rtc.h em_rtcc.h em_smu.h em_system.h em_timer.h em_usart.h em_vcmp.h em_vdac.h em_version.h em_wdog.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/: emac_lwip.c emac_stack_lwip.cpp eth_arch.h EthernetInterface.cpp EthernetInterface.h lwip_stack.c lwip_stack.h lwipopts.h ppp_lwip.cpp ppp_lwip.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/: etharp.h lowpan6.h lowpan6_opts.h lwip_ethernet.h slipif.h
    mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/source/: event.c event.h minar_hal_timer.cpp ns_timeout.c ns_timer.c ns_timer.h system_timer.c timer_sys.h
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    mbed-os/features/mbedtls/targets/: hash_wrappers.c
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: irq_cm4f.S
    mbed-os/features/filesystem/littlefs/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
    mbed-os/features/filesystem/littlefs/: LittleFileSystem.cpp LittleFileSystem.h
    mbed-os/features/lorawan/lorastack/phy/: lora_phy_ds.h LoRaPHY.cpp LoRaPHY.h LoRaPHYAS923.cpp LoRaPHYAS923.h LoRaPHYAU915.cpp LoRaPHYAU915.h LoRaPHYCN470.cpp LoRaPHYCN470.h LoRaPHYCN779.cpp LoRaPHYCN779.h LoRaPHYEU433.cpp LoRaPHYEU433.h LoRaPHYEU868.cpp LoRaPHYEU868.h LoRaPHYIN865.cpp LoRaPHYIN865.h LoRaPHYKR920.cpp LoRaPHYKR920.h LoRaPHYUS915.cpp LoRaPHYUS915.h LoRaPHYUS915Hybrid.cpp LoRaPHYUS915Hybrid.h
    mbed-os/features/lorawan/lorastack/mac/: LoRaMac.cpp LoRaMac.h LoRaMacChannelPlan.cpp LoRaMacChannelPlan.h LoRaMacCommand.cpp LoRaMacCommand.h LoRaMacCrypto.cpp LoRaMacCrypto.h LoRaMacMcps.cpp LoRaMacMcps.h LoRaMacMib.cpp LoRaMacMib.h LoRaMacMlme.cpp LoRaMacMlme.h
    mbed-os/features/lorawan/: LoRaRadio.h LoRaWANBase.h LoRaWANInterface.cpp LoRaWANInterface.h LoRaWANStack.cpp LoRaWANStack.h
    mbed-os/features/lorawan/system/: lorawan_data_structures.h LoRaWANTimer.cpp LoRaWANTimer.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/polarssl/: lwip_arc4.c lwip_des.c lwip_md4.c lwip_md5.c lwip_sha1.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/: lwip_auth.c lwip_ccp.c lwip_chap-md5.c lwip_chap-new.c lwip_chap_ms.c lwip_demand.c lwip_eap.c lwip_ecp.c lwip_eui64.c lwip_fsm.c lwip_ipcp.c lwip_ipv6cp.c lwip_lcp.c lwip_magic.c lwip_mppe.c lwip_multilink.c lwip_ppp.c lwip_pppapi.c lwip_pppcrypt.c lwip_pppoe.c lwip_pppol2tp.c lwip_pppos.c lwip_upap.c lwip_utils.c lwip_vj.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/: lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/: lwip_ethernet.c lwip_ethernetif.c lwip_lowpan6.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/: lwip_random.c lwip_random.h lwip_tcp_isn.c lwip_tcp_isn.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/: mbed.h
    mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp SysTimer.h
    mbed-os/targets/TARGET_Silicon_Labs/: mbed_rtx.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.c mbed_rtx_fault_handler.h
    mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/source/: mbed_trace.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/mbed-trace/: mbed_trace.h
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libList/: ns_list.c
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
    mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/nvm/: nvm_ram.c
    mbed-os/features/nvstore/source/: nvstore.cpp nvstore.h
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.cpp OnboardCellularInterface.h PPPCellularInterface.cpp PPPCellularInterface.h UARTCellularInterface.cpp UARTCellularInterface.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/: PeripheralPins.c
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/features/cellular/framework/targets/QUECTEL/BC95/: QUECTEL_BC95.cpp QUECTEL_BC95.h QUECTEL_BC95_CellularNetwork.cpp QUECTEL_BC95_CellularNetwork.h QUECTEL_BC95_CellularPower.cpp QUECTEL_BC95_CellularPower.h QUECTEL_BC95_CellularSIM.cpp QUECTEL_BC95_CellularSIM.h QUECTEL_BC95_CellularStack.cpp QUECTEL_BC95_CellularStack.h
    mbed-os/features/cellular/framework/targets/QUECTEL/BG96/: QUECTEL_BG96.cpp QUECTEL_BG96.h QUECTEL_BG96_CellularNetwork.cpp QUECTEL_BG96_CellularNetwork.h QUECTEL_BG96_CellularStack.cpp QUECTEL_BG96_CellularStack.h
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/source/: randLIB.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/: randLIB.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.c rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c RTX_Config.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/trng/: sl_trng.c sl_trng.h trng_api.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-coap/source/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    mbed-os/features/FEATURE_COMMON_PAL/mbed-coap/mbed-coap/: sn_coap_header.h sn_coap_protocol.h sn_config.h
    mbed-os/features/FEATURE_COMMON_PAL/mbed-coap/source/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    mbed-os/targets/TARGET_Silicon_Labs/TARGET_EFM32/TARGET_EFM32WG/device/TARGET_256K/TOOLCHAIN_ARM_STD/: startup_efm32wg.S
    mbed-os/features/cellular/framework/targets/TELIT/HE910/: TELIT_HE910.cpp TELIT_HE910.h TELIT_HE910_CellularNetwork.cpp TELIT_HE910_CellularNetwork.h TELIT_HE910_CellularPower.cpp TELIT_HE910_CellularPower.h
    mbed-os/features/cellular/framework/targets/UBLOX/LISA_U/: UBLOX_LISA_U.cpp UBLOX_LISA_U.h UBLOX_LISA_U_CellularNetwork.cpp UBLOX_LISA_U_CellularNetwork.h UBLOX_LISA_U_CellularPower.cpp UBLOX_LISA_U_CellularPower.h
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group mbed-os-bts-pa-cellular
    ./: main.cpp mbed_config.h
    ./: PursuitAlertRevCInterface.h PinDetect.h DebounceIn.h InitDevice.h InitDevice.cpp
    ./nimbelink/: NL_SW_LTE_TSVG.h
